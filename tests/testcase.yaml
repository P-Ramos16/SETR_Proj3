## tests/testcase.yaml
```yaml
tests:
  proj3_tests:
    platform_allow: nrf52840dk_nrf52840
    tags: proj3_tests
```
